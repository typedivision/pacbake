## meta/recipes-core/sysfiles/config/Kconfig
```kconfig
menu "System"

config SYS_HOSTNAME
    string "system hostname"
    default ""
    help
      The system's hostname.

endmenu
```
