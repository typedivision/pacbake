PD = "Basic image with extra packages"

require image-basic.inc

IMAGE_PKGS += "iw python python-rpi.gpio"
